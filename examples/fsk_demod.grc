<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_demod</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ad_samp_rate</value></param>
<param><key>value</key><value>symb_rate*first_dec*sec_dec*samp_per_symb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>first_dec</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation</value></param>
<param><key>value</key><value>104167</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_symb</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sec_dec</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symb_rate</value></param>
<param><key>value</key><value>52083</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>ad_samp_rate/(first_dec*sec_dec*2*math.pi*fsk_deviation/8.0)</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>samp_per_symb</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.0</value></param>
<param><key>ted_gain</key><value>1.0</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>0.03</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>samp_per_symb</value></param>
<param><key>ted_type</key><value>digital.TED_GARDNER</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>ad_samp_rate/first_dec/sec_dec</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0:[2,0,2,4]</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-160</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui_tab_widget_0</value></param>
<param><key>label0</key><value>Frequency Plot</value></param>
<param><key>label1</key><value>Demod Bits</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>ad_samp_rate/first_dec/sec_dec</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>ad_samp_rate/first_dec/sec_dec</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0:[0,0,2,4]</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
