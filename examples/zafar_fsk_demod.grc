<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>zafar_fsk_demod</value></param>
<param><key>category</key><value>[GRC Hier Blocks/Zafar]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Zafar FSK Demodulator</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*fsk_deviation/8.0)</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>samp_per_symb</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.0</value></param>
<param><key>ted_gain</key><value>1.0</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>0.03</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>samp_per_symb</value></param>
<param><key>ted_type</key><value>digital.TED_GARDNER</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fsk_deviation</value></param>
<param><key>label</key><value>FSK Deviation</value></param>
<param><key>value</key><value>104167</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_per_symb</value></param>
<param><key>label</key><value>Sample per Symbol</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
