<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tbhp</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MTU</value></param>
<param><key>value</key><value>1500</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ad9361rx_lo_freq</value></param>
<param><key>value</key><value>437000000</value></param>
<param><key>gui_hint</key><value>tm_tab_control@0:[0,0,1,4]</value></param>
<param><key>label</key><value>AD9361 LO Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adrx_channel_bw</value></param>
<param><key>value</key><value>adrx_samp_rate/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adrx_samp_rate</value></param>
<param><key>value</key><value>520830*6</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bc_ad9361_lo_freq</value></param>
<param><key>value</key><value>438000000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>bc_tab_control@0:[0,0,1,4]</value></param>
<param><key>label</key><value>AD9361 LO Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bc_channel_bw</value></param>
<param><key>value</key><value>bc_symb_rate*bc_samp_per_symb/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bc_dec1</value></param>
<param><key>value</key><value>5*10</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bc_doppler</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>bc_tab_control@0:[1,2,1,2]</value></param>
<param><key>label</key><value>Doppler</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bc_f_if</value></param>
<param><key>value</key><value>5000</value></param>
<param><key>gui_hint</key><value>bc_tab_control@0:[1,0,1,2]</value></param>
<param><key>label</key><value>IF Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bc_filt_sharp</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bc_gain_before_tr</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>bc_tab_control@1:[1,0,1,4]</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>min_len</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.1</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bc_pll_loopbw_range</value></param>
<param><key>value</key><value>0.15</value></param>
<param><key>gui_hint</key><value>bc_tab_control@1:[0,0,1,4]</value></param>
<param><key>label</key><value>PLL LBW</value></param>
<param><key>min_len</key><value>10000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bc_rrc_dec</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bc_samp_per_symb</value></param>
<param><key>value</key><value>80</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>bc_source_option</value></param>
<param><key>value</key><value>(0,1)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>bc_tab_control@0:[2,0,1,4]</value></param>
<param><key>label0</key><value>AD9361</value></param>
<param><key>label1</key><value>File</value></param>
<param><key>label</key><value>Source From</value></param>
<param><key>labels</key><value>["File","AD9361"]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>(1,0)</value></param>
<param><key>option1</key><value>(0,1)</value></param>
<param><key>options</key><value>[0, 1]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bc_ss_damping_factor_range</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>gui_hint</key><value>bc_tab_control@2:[2,0,1,4]</value></param>
<param><key>label</key><value>Symbol Sync DF</value></param>
<param><key>min_len</key><value>10000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bc_ss_loopbw_range</value></param>
<param><key>value</key><value>0.2</value></param>
<param><key>gui_hint</key><value>bc_tab_control@2:[0,0,1,4]</value></param>
<param><key>label</key><value>Symbol Sync LBW</value></param>
<param><key>min_len</key><value>10000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bc_ss_ted_gain_range</value></param>
<param><key>value</key><value>300</value></param>
<param><key>gui_hint</key><value>bc_tab_control@2:[1,0,1,4]</value></param>
<param><key>label</key><value>Symbol Sync TED gain</value></param>
<param><key>min_len</key><value>10000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bc_symb_rate</value></param>
<param><key>value</key><value>270</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bc_waterfall_per</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>bc_tab_control@0:[3,0,1,4]</value></param>
<param><key>label</key><value>Waterfall Plot Period</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec_cc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>MTU*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>frx_if</value></param>
<param><key>value</key><value>75000</value></param>
<param><key>gui_hint</key><value>tm_tab_control@0:[1,0,1,2]</value></param>
<param><key>label</key><value>IF Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[109, 79]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tm_channel_bw</value></param>
<param><key>value</key><value>tm_symb_rate*1.5+frx_if</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tm_dec1</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tm_gain_before_tr</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>tm_tab_control@1:[1,0,1,4]</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>min_len</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.1</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tm_pll_loopbw_range</value></param>
<param><key>value</key><value>0.3</value></param>
<param><key>gui_hint</key><value>tm_tab_control@1:[0,0,1,4]</value></param>
<param><key>label</key><value>PLL LBW</value></param>
<param><key>min_len</key><value>10000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tm_samp_per_symb</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tm_ss_damping_factor_range</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>gui_hint</key><value>tm_tab_control@2:[2,0,1,4]</value></param>
<param><key>label</key><value>Symbol Sync DF</value></param>
<param><key>min_len</key><value>10000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tm_ss_loopbw_range</value></param>
<param><key>value</key><value>0.4</value></param>
<param><key>gui_hint</key><value>tm_tab_control@2:[0,0,1,4]</value></param>
<param><key>label</key><value>Symbol Sync LBW</value></param>
<param><key>min_len</key><value>10000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tm_ss_ted_gain_range</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>tm_tab_control@2:[1,0,1,4]</value></param>
<param><key>label</key><value>Symbol Sync TED gain</value></param>
<param><key>min_len</key><value>10000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tm_symb_rate</value></param>
<param><key>value</key><value>52083</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tm_waterfall_per</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>tm_tab_control@0:[3,0,1,4]</value></param>
<param><key>label</key><value>Waterfall Plot Period</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>analog_pll_freqdet_cf</key>
<param><key>id</key><value>analog_pll_freqdet_cf_0</value></param>
<param><key>w</key><value>tm_pll_loopbw_range</value></param>
<param><key>max_freq</key><value>tm_channel_bw*6.28/(adrx_samp_rate/tm_dec1)</value></param>
<param><key>min_freq</key><value>-tm_channel_bw*6.28/(adrx_samp_rate/tm_dec1)</value></param>
</block>
<block>
<key>analog_pll_freqdet_cf</key>
<param><key>id</key><value>analog_pll_freqdet_cf_0_0</value></param>
<param><key>w</key><value>bc_pll_loopbw_range</value></param>
<param><key>max_freq</key><value>20000*6.28/(adrx_samp_rate/bc_dec1)</value></param>
<param><key>min_freq</key><value>0*6.28/(adrx_samp_rate/bc_dec1)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-(1000000+(frx_if-bc_f_if))</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>adrx_samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>1.25e6+75e3</value></param>
<param><key>low_cutoff_freq</key><value>750e3+75e3</value></param>
<param><key>samp_rate</key><value>adrx_samp_rate</value></param>
<param><key>width</key><value>50e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>bc_tab_control</value></param>
<param><key>gui_hint</key><value>tabs@2:[0,0,3,1]</value></param>
<param><key>label0</key><value>General</value></param>
<param><key>label1</key><value>GMSK Demodulator</value></param>
<param><key>label2</key><value>Gardner Timing Recovery</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>bc_tab_plot</value></param>
<param><key>gui_hint</key><value>tabs@2:[0,1,4,3]</value></param>
<param><key>label0</key><value>Frequency Plot</value></param>
<param><key>label1</key><value>Time Plot</value></param>
<param><key>label2</key><value>Demoded Bits 1</value></param>
<param><key>label3</key><value>Demoded Bits 2</value></param>
<param><key>label4</key><value>Decoded Data (Viterbi)</value></param>
<param><key>label5</key><value>Decoded Data (RS)</value></param>
<param><key>label6</key><value>Decrypted Data</value></param>
<param><key>num_tabs</key><value>7</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>bc_tab_stat</value></param>
<param><key>gui_hint</key><value>tabs@2:[3,0,1,1]</value></param>
<param><key>label0</key><value>General</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>beacon_baseband_sink</value></param>
<param><key>stream_id</key><value>beacon_baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>beacon_baseband_source</value></param>
<param><key>stream_id</key><value>beacon_baseband</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>63</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>63</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/iust/Documents/zafar_prj/gr-iustsat/examples/ReceivedData/BeaconReceivedData.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/iust/Documents/zafar_prj/gr-iustsat/examples/ReceivedData/TelemetryReceivedData.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const</value></param>
<param><key>const</key><value>tm_gain_before_tr</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_0</value></param>
<param><key>const</key><value>bc_gain_before_tr</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>0.066666667</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pkt_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pkt_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>frm_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>frm_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>frm_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>frm_len</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0_0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>crypto_auth_dec_aes_gcm</key>
<param><key>id</key><value>crypto_auth_dec_aes_gcm_0_0</value></param>
<param><key>ivlen</key><value>96</value></param>
<param><key>keylen</key><value>16</value></param>
<param><key>key</key><value>[0xFE, 0xFF, 0xE9, 0x92, 0x86, 0x65, 0x73, 0x1C, 0x6D, 0x6A, 0x8F, 0x94, 0x67, 0x30, 0x83, 0x08]</value></param>
</block>
<block>
<key>crypto_auth_dec_aes_gcm</key>
<param><key>id</key><value>crypto_auth_dec_aes_gcm_0_0_0</value></param>
<param><key>ivlen</key><value>96</value></param>
<param><key>keylen</key><value>16</value></param>
<param><key>key</key><value>[0xFE, 0xFF, 0xE9, 0x92, 0x86, 0x65, 0x73, 0x1C, 0x6D, 0x6A, 0x8F, 0x94, 0x67, 0x30, 0x83, 0x08]</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>65536</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0</value></param>
<param><key>length</key><value>20000</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>tm_ss_damping_factor_range</value></param>
<param><key>ted_gain</key><value>tm_ss_ted_gain_range</value></param>
<param><key>nfilters</key><value>128</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_PFB_NO_MF</value></param>
<param><key>loop_bw</key><value>tm_ss_loopbw_range</value></param>
<param><key>max_dev</key><value>2</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>tm_samp_per_symb</value></param>
<param><key>ted_type</key><value>digital.TED_GARDNER</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0_0</value></param>
<param><key>damping</key><value>bc_ss_damping_factor_range</value></param>
<param><key>ted_gain</key><value>bc_ss_ted_gain_range</value></param>
<param><key>nfilters</key><value>32</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_PFB_NO_MF</value></param>
<param><key>loop_bw</key><value>bc_ss_loopbw_range</value></param>
<param><key>max_dev</key><value>2</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>23.148</value></param>
<param><key>ted_type</key><value>digital.TED_GARDNER</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0</value></param>
<param><key>decoder</key><value>dec_cc</value></param>
<param><key>mtu</key><value>MTU</value></param>
<param><key>packed</key><value>True</value></param>
<param><key>rev_pack</key><value>False</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0_0</value></param>
<param><key>decoder</key><value>dec_cc</value></param>
<param><key>mtu</key><value>MTU</value></param>
<param><key>packed</key><value>True</value></param>
<param><key>rev_pack</key><value>False</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[1,1,1,-1,1,-1,-1,1,-1,-1,1,-1,1,-1,-1,1,1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,-1,1,-1,1,1,1,-1,1,-1,1,1,1,-1,-1,-1,-1,-1,-1]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[1,1,1,-1,1,-1,-1,1,-1,-1,1,-1,1,-1,-1,1,1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,-1,1,-1,1,1,1,-1,1,-1,1,1,1,-1,-1,-1,-1,-1,-1]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>iio_fmcomms2_source</key>
<param><key>id</key><value>iio_fmcomms2_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>gain1</key><value>"fast_attack"</value></param>
<param><key>uri</key><value>192.168.1.10</value></param>
<param><key>frequency</key><value>ad9361rx_lo_freq-frx_if</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>rf_port_select</key><value>"A_BALANCED"</value></param>
<param><key>bandwidth</key><value>adrx_channel_bw*5</value></param>
<param><key>rx1_en</key><value>True</value></param>
<param><key>rx2_en</key><value>False</value></param>
<param><key>samplerate</key><value>adrx_samp_rate</value></param>
</block>
<block>
<key>iustsat_frame_analysis</key>
<param><key>id</key><value>iustsat_frame_analysis_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>frm_len</value></param>
</block>
<block>
<key>iustsat_pdu_debug</key>
<param><key>id</key><value>iustsat_pdu_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>meta_tag_key</key><value>auth_tag</value></param>
</block>
<block>
<key>iustsat_pdu_debug</key>
<param><key>id</key><value>iustsat_pdu_debug_0_0_0</value></param>
<param><key>meta_tag_key</key><value>auth_tag</value></param>
</block>
<block>
<key>iustsat_pdu_debug_2</key>
<param><key>id</key><value>iustsat_pdu_debug_2_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>meta_tag_key</key><value>aad</value></param>
<param><key>meta2_tag_key</key><value>auth_tag</value></param>
</block>
<block>
<key>iustsat_pdu_debug_2</key>
<param><key>id</key><value>iustsat_pdu_debug_2_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>meta_tag_key</key><value>aad</value></param>
<param><key>meta2_tag_key</key><value>auth_tag</value></param>
</block>
<block>
<key>iustsat_pdu_to_message</key>
<param><key>id</key><value>iustsat_pdu_to_message_0</value></param>
<param><key>len_tag_key</key><value>frm_len</value></param>
</block>
<block>
<key>iustsat_pdu_to_message</key>
<param><key>id</key><value>iustsat_pdu_to_message_0_0</value></param>
<param><key>len_tag_key</key><value>frm_len</value></param>
</block>
<block>
<key>iustsat_rs_to_decrypt</key>
<param><key>id</key><value>iustsat_rs_to_decrypt_0_0</value></param>
<param><key>aad_key</key><value>aad</value></param>
<param><key>iv_key</key><value>iv</value></param>
<param><key>iv</key><value>[0xCA, 0xFE, 0xBA, 0xBE, 0xFA, 0xCE, 0xDB, 0xAD, 0xDE, 0xCA, 0xF8, 0x88]</value></param>
<param><key>tag_key</key><value>auth_tag</value></param>
</block>
<block>
<key>iustsat_synch_detect_tag</key>
<param><key>id</key><value>iustsat_synch_detect_tag_1</value></param>
<param><key>length_key</key><value>pkt_len</value></param>
<param><key>length</key><value>259*2*8</value></param>
<param><key>threshold</key><value>60</value></param>
</block>
<block>
<key>iustsat_synch_detect_tag</key>
<param><key>id</key><value>iustsat_synch_detect_tag_1_0</value></param>
<param><key>length_key</key><value>pkt_len</value></param>
<param><key>length</key><value>93*2*8</value></param>
<param><key>threshold</key><value>60</value></param>
</block>
<block>
<key>iustsat_tag_counter</key>
<param><key>id</key><value>iustsat_tag_counter_0</value></param>
<param><key>key</key><value>pkt_len</value></param>
</block>
<block>
<key>iustsat_tag_counter</key>
<param><key>id</key><value>iustsat_tag_counter_0_0</value></param>
<param><key>key</key><value>pkt_len</value></param>
</block>
<block>
<key>iustsat_vt_to_decrypt</key>
<param><key>id</key><value>iustsat_vt_to_decrypt_0</value></param>
<param><key>aad_key</key><value>aad</value></param>
<param><key>iv_key</key><value>iv</value></param>
<param><key>iv</key><value>[0xCA, 0xFE, 0xBA, 0xBE, 0xFA, 0xCE, 0xDB, 0xAD, 0xDE, 0xCA, 0xF8, 0x88]</value></param>
<param><key>tag_key</key><value>auth_tag</value></param>
</block>
<block>
<key>iustsat_zafar_telemetry_derand</key>
<param><key>id</key><value>iustsat_zafar_telemetry_derand_0</value></param>
<param><key>pkt_len_key</key><value>"pkt_len"</value></param>
</block>
<block>
<key>iustsat_zafar_telemetry_derand</key>
<param><key>id</key><value>iustsat_zafar_telemetry_derand_0_0</value></param>
<param><key>pkt_len_key</key><value>"pkt_len"</value></param>
</block>
<block>
<key>iustsat_zafar_telemetry_frame_extractor</key>
<param><key>id</key><value>iustsat_zafar_telemetry_frame_extractor_1</value></param>
<param><key>s</key><value>"pkt_len"</value></param>
</block>
<block>
<key>iustsat_zafar_telemetry_frame_extractor</key>
<param><key>id</key><value>iustsat_zafar_telemetry_frame_extractor_1_0</value></param>
<param><key>s</key><value>"pkt_len"</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>tm_channel_bw</value></param>
<param><key>decim</key><value>tm_dec1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>adrx_samp_rate</value></param>
<param><key>width</key><value>tm_channel_bw/20</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>bc_channel_bw</value></param>
<param><key>decim</key><value>bc_dec1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>adrx_samp_rate</value></param>
<param><key>width</key><value>bc_channel_bw/bc_filt_sharp</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>adrx_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tm_tab_plot@0</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>tm_tab_stat@0:[0,2,2,1]</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Counter</value></param>
<param><key>label2</key><value>Rate (bps)</value></param>
<param><key>name</key><value>"Received Frame Counter"</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>gui_hint</key><value>bc_tab_stat@0:[0,2,2,1]</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Counter</value></param>
<param><key>label2</key><value>Rate (bps)</value></param>
<param><key>name</key><value>"Received Frame Counter"</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tm_tab_stat@0:[0,3,2,1]</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Counter</value></param>
<param><key>label2</key><value>Rate (bps)</value></param>
<param><key>name</key><value>"Decrypted Frame Counter"</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tm_tab_plot@1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>size</key><value>3000</value></param>
<param><key>srate</key><value>adrx_samp_rate/tm_dec1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>10</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>bc_tab_plot@1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>size</key><value>3000</value></param>
<param><key>srate</key><value>adrx_samp_rate/bc_dec1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>10</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tm_tab_plot@3:[0,0,2,4]</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>size</key><value>4144</value></param>
<param><key>srate</key><value>tm_symb_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"pkt_len"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>bc_tab_plot@2</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>size</key><value>90*2*8+200</value></param>
<param><key>srate</key><value>bc_symb_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"pkt_len"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tm_tab_plot@5</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>name</key><value>"Reed-Solomon Decoder Out"</value></param>
<param><key>size</key><value>223</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"pkt_len"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>300</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_1_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tm_tab_plot@4</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>name</key><value>"Viterbi Decoder Out"</value></param>
<param><key>size</key><value>255</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"pkt_len"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>300</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_1_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tm_tab_plot@6</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>name</key><value>"GCM-AES Decryptor Out"</value></param>
<param><key>size</key><value>203</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"frm_len"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>300</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>adrx_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tm_tab_plot@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>tm_waterfall_per</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>adrx_samp_rate/bc_dec1</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>bc_tab_plot@0:[2,0,2,4]</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_min</key><value>-170</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>bc_waterfall_per</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.7</value></param>
<param><key>decim</key><value>bc_rrc_dec</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>ntaps</key><value>32</value></param>
<param><key>samp_rate</key><value>adrx_samp_rate/bc_dec1</value></param>
<param><key>sym_rate</key><value>bc_symb_rate</value></param>
</block>
<block>
<key>satellites_decode_rs_general</key>
<param><key>id</key><value>satellites_decode_rs_general_0</value></param>
<param><key>gfpoly</key><value>285</value></param>
<param><key>fcr</key><value>0</value></param>
<param><key>nroots</key><value>32</value></param>
<param><key>output_failed</key><value>False</value></param>
<param><key>prim</key><value>1</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>Telemetry</value></param>
<param><key>label1</key><value>Telecommand</value></param>
<param><key>label2</key><value>Beacon</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tm_tab_control</value></param>
<param><key>gui_hint</key><value>tabs@0:[0,0,3,1]</value></param>
<param><key>label0</key><value>General</value></param>
<param><key>label1</key><value>GMSK Demodulator</value></param>
<param><key>label2</key><value>Gardner Timing Recovery</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tm_tab_plot</value></param>
<param><key>gui_hint</key><value>tabs@0:[0,1,4,3]</value></param>
<param><key>label0</key><value>Frequency Plot</value></param>
<param><key>label1</key><value>Time Plot</value></param>
<param><key>label2</key><value>Demoded Bits 1</value></param>
<param><key>label3</key><value>Demoded Bits 2</value></param>
<param><key>label4</key><value>Decoded Data (Viterbi)</value></param>
<param><key>label5</key><value>Decoded Data (RS)</value></param>
<param><key>label6</key><value>Decrypted Data</value></param>
<param><key>num_tabs</key><value>7</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tm_tab_stat</value></param>
<param><key>gui_hint</key><value>tabs@0:[3,0,1,1]</value></param>
<param><key>label0</key><value>General</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<connection><source_block_id>analog_pll_freqdet_cf_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_freqdet_cf_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beacon_baseband_source</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>iustsat_synch_detect_tag_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>iustsat_synch_detect_tag_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>beacon_baseband_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_uchar_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_uchar_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0_0</source_block_id><sink_block_id>blocks_float_to_uchar_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0_0_0</source_block_id><sink_block_id>blocks_float_to_uchar_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0_1</source_block_id><sink_block_id>qtgui_number_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_auth_dec_aes_gcm_0_0</source_block_id><sink_block_id>iustsat_pdu_debug_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>crypto_auth_dec_aes_gcm_0_0</source_block_id><sink_block_id>iustsat_pdu_to_message_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>crypto_auth_dec_aes_gcm_0_0_0</source_block_id><sink_block_id>iustsat_frame_analysis_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>crypto_auth_dec_aes_gcm_0_0_0</source_block_id><sink_block_id>iustsat_pdu_debug_0_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>crypto_auth_dec_aes_gcm_0_0_0</source_block_id><sink_block_id>iustsat_pdu_to_message_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_multiply_const</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0</source_block_id><sink_block_id>blocks_uchar_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0_0</source_block_id><sink_block_id>blocks_tag_gate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0</source_block_id><sink_block_id>iustsat_zafar_telemetry_derand_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0_0</source_block_id><sink_block_id>iustsat_zafar_telemetry_derand_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>iustsat_synch_detect_tag_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>iustsat_synch_detect_tag_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iustsat_frame_analysis_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>iustsat_frame_analysis_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0_0_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>iustsat_pdu_to_message_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>iustsat_pdu_to_message_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0_0_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>iustsat_rs_to_decrypt_0_0</source_block_id><sink_block_id>crypto_auth_dec_aes_gcm_0_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>iustsat_rs_to_decrypt_0_0</source_block_id><sink_block_id>iustsat_pdu_debug_2_0_0_0</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>iustsat_synch_detect_tag_1</source_block_id><sink_block_id>iustsat_tag_counter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iustsat_synch_detect_tag_1</source_block_id><sink_block_id>iustsat_zafar_telemetry_frame_extractor_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iustsat_synch_detect_tag_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iustsat_synch_detect_tag_1_0</source_block_id><sink_block_id>iustsat_tag_counter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iustsat_synch_detect_tag_1_0</source_block_id><sink_block_id>iustsat_zafar_telemetry_frame_extractor_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iustsat_synch_detect_tag_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iustsat_tag_counter_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iustsat_tag_counter_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iustsat_tag_counter_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iustsat_tag_counter_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iustsat_vt_to_decrypt_0</source_block_id><sink_block_id>crypto_auth_dec_aes_gcm_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>iustsat_vt_to_decrypt_0</source_block_id><sink_block_id>iustsat_pdu_debug_2_0_0</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>iustsat_zafar_telemetry_derand_0</source_block_id><sink_block_id>iustsat_vt_to_decrypt_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>iustsat_zafar_telemetry_derand_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>iustsat_zafar_telemetry_derand_0_0</source_block_id><sink_block_id>satellites_decode_rs_general_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>iustsat_zafar_telemetry_frame_extractor_1</source_block_id><sink_block_id>fec_async_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>iustsat_zafar_telemetry_frame_extractor_1_0</source_block_id><sink_block_id>fec_async_decoder_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_pll_freqdet_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>analog_pll_freqdet_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_general_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_general_0</source_block_id><sink_block_id>iustsat_rs_to_decrypt_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
